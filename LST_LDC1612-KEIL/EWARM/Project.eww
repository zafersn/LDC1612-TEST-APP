<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\LST_LDC1612.ewp</path>
  </project>
  <batchBuild />
</workspace>
